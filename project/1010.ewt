<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>APP</name>
    <file>
      <name>$PROJ_DIR$\..\source\app\source\task.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\app\source\task_comm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\app\source\task_device.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\app\source\task_glucose.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\app\source\task_history.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\app\source\task_setting.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\app\source\task_shell.c</name>
    </file>
  </group>
  <group>
    <name>CORE</name>
    <file>
      <name>$PROJ_DIR$\..\source\stm8l\stm8l15x_it.c</name>
    </file>
  </group>
  <group>
    <name>DRIVERS</name>
    <file>
      <name>$PROJ_DIR$\..\source\driver\source\drv.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\driver\source\drv_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\driver\source\drv_beep.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\driver\source\drv_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\driver\source\drv_eeprom.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\driver\source\drv_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\driver\source\drv_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\driver\source\drv_lcd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\driver\source\drv_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\driver\source\drv_uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\driver\source\drv_voice.c</name>
    </file>
  </group>
  <group>
    <name>LIBRARY</name>
    <file>
      <name>$PROJ_DIR$\..\source\library\midware\source\devcomm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\library\midware\source\devfs.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\library\midware\source\devos.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\library\library\source\lib_checksum.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\library\library\source\lib_frame.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\library\library\source\lib_heap.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\library\library\source\lib_parser.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\library\library\source\lib_queue.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\library\library\source\lib_string.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\library\library\source\lib_timer.c</name>
    </file>
  </group>
  <group>
    <name>MIDWARE</name>
    <file>
      <name>$PROJ_DIR$\..\source\midware\source\bluetooth.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\midware\source\button.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\midware\source\glucose.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\midware\source\mid.c</name>
    </file>
  </group>
  <group>
    <name>STM8L</name>
    <file>
      <name>$PROJ_DIR$\..\source\stm8l\STM8L15x_StdPeriph_Driver\src\stm8l15x_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\stm8l\STM8L15x_StdPeriph_Driver\src\stm8l15x_aes.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\stm8l\STM8L15x_StdPeriph_Driver\src\stm8l15x_beep.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\stm8l\STM8L15x_StdPeriph_Driver\src\stm8l15x_clk.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\stm8l\STM8L15x_StdPeriph_Driver\src\stm8l15x_comp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\stm8l\STM8L15x_StdPeriph_Driver\src\stm8l15x_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\stm8l\STM8L15x_StdPeriph_Driver\src\stm8l15x_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\stm8l\STM8L15x_StdPeriph_Driver\src\stm8l15x_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\stm8l\STM8L15x_StdPeriph_Driver\src\stm8l15x_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\stm8l\STM8L15x_StdPeriph_Driver\src\stm8l15x_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\stm8l\STM8L15x_StdPeriph_Driver\src\stm8l15x_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\stm8l\STM8L15x_StdPeriph_Driver\src\stm8l15x_irtim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\stm8l\STM8L15x_StdPeriph_Driver\src\stm8l15x_itc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\stm8l\STM8L15x_StdPeriph_Driver\src\stm8l15x_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\stm8l\STM8L15x_StdPeriph_Driver\src\stm8l15x_lcd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\stm8l\STM8L15x_StdPeriph_Driver\src\stm8l15x_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\stm8l\STM8L15x_StdPeriph_Driver\src\stm8l15x_rst.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\stm8l\STM8L15x_StdPeriph_Driver\src\stm8l15x_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\stm8l\STM8L15x_StdPeriph_Driver\src\stm8l15x_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\stm8l\STM8L15x_StdPeriph_Driver\src\stm8l15x_syscfg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\stm8l\STM8L15x_StdPeriph_Driver\src\stm8l15x_tim1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\stm8l\STM8L15x_StdPeriph_Driver\src\stm8l15x_tim2.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\stm8l\STM8L15x_StdPeriph_Driver\src\stm8l15x_tim3.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\stm8l\STM8L15x_StdPeriph_Driver\src\stm8l15x_tim4.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\stm8l\STM8L15x_StdPeriph_Driver\src\stm8l15x_tim5.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\stm8l\STM8L15x_StdPeriph_Driver\src\stm8l15x_usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\stm8l\STM8L15x_StdPeriph_Driver\src\stm8l15x_wfe.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\stm8l\STM8L15x_StdPeriph_Driver\src\stm8l15x_wwdg.c</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\..\source\app\source\main.c</name>
  </file>
</project>


