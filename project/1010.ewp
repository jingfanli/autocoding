# IAR project 1010.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151M8 STM8L151M8
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15X_HD; RAM_EXECUTION=1
  ICCSTM8.CCIncludePath2: ..\source\stm8l; ..\source\app\include; ..\source\driver\include; ..\source\midware\include; ..\source\global; ..\source\stm8l\STM8L15x_StdPeriph_Driver\inc; ..\source\library\library\include; ..\source\library\global; ..\source\library\midware\include; ..\source\library
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: 1010.hex
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ../source/app/source/: main.c
  group APP
    ../source/app/source/: task.c task_comm.c task_device.c task_glucose.c task_history.c task_setting.c task_shell.c
  group CORE
    ../source/stm8l/: stm8l15x_it.c
  group DRIVERS
    ../source/driver/source/: drv.c drv_adc.c drv_beep.c drv_dac.c drv_eeprom.c drv_flash.c drv_gpio.c drv_lcd.c drv_rtc.c drv_uart.c drv_voice.c
  group LIBRARY
    ../source/library/midware/source/: devcomm.c devfs.c devos.c
    ../source/library/library/source/: lib_checksum.c lib_frame.c lib_heap.c lib_parser.c lib_queue.c lib_string.c lib_timer.c
  group MIDWARE
    ../source/midware/source/: bluetooth.c button.c glucose.c mid.c
  group STM8L
    ../source/stm8l/STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
